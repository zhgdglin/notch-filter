# Keil uVision project Demo_DSSS.uvprojx, settings and files
target Demo_DSSS (5060960::V5.06 update 7 (build 960)::.\ARMAC5)
  device: STM32H743IITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: DSSS +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=6 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER, STM32H743xx,ARM_MATH_CM7,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ..\CORE;..\USER;..\DSPLIB;..\DSPLIB\Include;..\SYSTEM\delay;..\SYSTEM\sys;..\FATFS\source;..\FATFS\exfuns;..\HALLIB\STM32H7xx_HAL_Driver\Inc;..\HALLIB\STM32H7xx_HAL_Driver\Inc\Legacy;..\HALLIB\STM32H7xx_HAL_Driver\Src;..\SOFTWARE;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\TIMER;..\HARDWARE\MPU;..\HARDWARE\SDRAM;..\HARDWARE\SDMMC;..\HARDWARE\NAND;..\HARDWARE\QSPI;..\HARDWARE\RTC;..\HARDWARE\KEY;..\HARDWARE\EXTI;..\HARDWARE\MALLOC;..\HARDWARE\USART;..\HARDWARE\QSPI;..\HARDWARE\IIC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group CORE
    ../CORE/: core_cm7.h cmsis_armcc.h cmsis_compiler.h startup_stm32h743xx.s
  group HALLIB
    ../HALLIB/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_ll_fmc.c stm32h7xx_hal_sdram.c stm32h7xx_hal_nand.c stm32h7xx_hal_qspi.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_sram.c
  group FATFS
    ../FATFS/exfuns/: exfuns.c fattester.c
    ../FATFS/source/: diskio.c ff.c ffsystem.c ffunicode.c
  group DSPLIB
    ../DSPLIB/: arm_cortexM7lfdp_math.lib
    ../DSPLIB/Include/: arm_common_tables.h arm_const_structs.h arm_math.h
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/delay/: delay.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/NAND/: ftl.c nand.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/QSPI/: qspi.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/USART/: usart.c
    ../HARDWARE/MALLOC/: malloc.c
    ../HARDWARE/SDRAM/: sdram.c
    ../HARDWARE/SDMMC/: sdmmc.c
    ../HARDWARE/IIC/: iic.c
  group SOFTWARE
    ../SOFTWARE/: sys_init.c function.c logic_ctrl.c parameter.c modulate.c demodulate.c store.c
  group USER
    ./: main.c stm32h7xx_it.c system_stm32h7xx.c stm32h7xx_hal_msp.c
