# Keil uVision project project.uvprojx, settings and files
target DemoLatest (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H743XIHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: output +hex
  AfterMake: CopyHex_Flash.bat
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32H743xx,ARM_MATH_CM7,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,ARM_MATH_LOOPUNROLL
  c include: ..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\DSP\Include;..\..\Libraries\CMSIS\DSP\PrivateInclude;..\..\Libraries\CMSIS\Device\ST\STM32H7xx\Include;..\..\Libraries\STM32H7xx_HAL_Driver\Inc;..\..\User;..\..\User\app;..\..\User\bsp;..\..\User\bsp\inc;..\..\Libraries\FATFS\src;..\..\Libraries\FATFS\src\drivers
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  link misc: --diag_suppress 6314
  group APP
    ../../User/app/: Parameter.c Parameter.h Function.c malloc.c ConvDeCoder_BCJR.c ConvEnCoder.c LogicCtrl.c
  group BSP
    ../../User/bsp/: bsp.c bsp.h stm32h7xx_it.c
    ../../User/bsp/src/: bsp_beep.c bsp_dwt.c bsp_fmc_io.c bsp_fmc_sdram.c bsp_gpio.c bsp_key.c bsp_led.c bsp_qspi_w25q256.c bsp_sdio_sd.c bsp_spi_bus.c bsp_timer.c bsp_tim_pwm.c bsp_uart_fifo.c bsp_qspi.c bsp_fatfs.c bsp_rtc.c
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
  group DSP
    ../../Libraries/CMSIS/DSP/Source/BasicMathFunctions/: BasicMathFunctions.c
    ../../Libraries/CMSIS/DSP/Source/BayesFunctions/: BayesFunctions.c
    ../../Libraries/CMSIS/DSP/Source/CommonTables/: CommonTables.c
    ../../Libraries/CMSIS/DSP/Source/ComplexMathFunctions/: ComplexMathFunctions.c
    ../../Libraries/CMSIS/DSP/Source/ControllerFunctions/: ControllerFunctions.c
    ../../Libraries/CMSIS/DSP/Source/DistanceFunctions/: DistanceFunctions.c
    ../../Libraries/CMSIS/DSP/Source/FastMathFunctions/: FastMathFunctions.c
    ../../Libraries/CMSIS/DSP/Source/FilteringFunctions/: FilteringFunctions.c
    ../../Libraries/CMSIS/DSP/Source/InterpolationFunctions/: InterpolationFunctions.c
    ../../Libraries/CMSIS/DSP/Source/MatrixFunctions/: MatrixFunctions.c
    ../../Libraries/CMSIS/DSP/Source/QuaternionMathFunctions/: QuaternionMathFunctions.c
    ../../Libraries/CMSIS/DSP/Source/StatisticsFunctions/: StatisticsFunctions.c
    ../../Libraries/CMSIS/DSP/Source/SupportFunctions/: SupportFunctions.c
    ../../Libraries/CMSIS/DSP/Source/SVMFunctions/: SVMFunctions.c
    ../../Libraries/CMSIS/DSP/Source/TransformFunctions/: TransformFunctions.c
    ../../Libraries/CMSIS/DSP/Source/WindowFunctions/: WindowFunctions.c
  group FATFS
    ../../Libraries/FatFs/src/: ff.c ffconf.h diskio.c ff_gen_drv.c
    ../../Libraries/FatFs/src/option/: syscall.c cc936.c
    ../../Libraries/FatFs/src/drivers/: sd_diskio_dma.c
  group HAL
    ../../User/bsp/: stm32h7xx_hal_conf.h
    ../../Libraries/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_gpio.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_ll_fmc.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_sram.c stm32h7xx_hal_mdma.c stm32h7xx_hal_sd.c stm32h7xx_ll_sdmmc.c stm32h7xx_ll_delayblock.c stm32h7xx_hal_sdram.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_rtc.c stm32h7xx_hal_qspi.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_usart_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_iwdg.c
  group MDK-ARM
    ../../Libraries/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h743xx.s
  group User
    ../../User/: main.c
