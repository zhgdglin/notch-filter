# Keil uVision project BJC_2.uvprojx, settings and files
target BJC_2 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H750VBTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x801FFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: BJC_2 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32H750xx,ARM_MATH_LOOPUNROLL
  c include: ../Core/Inc;../FATFS/Target;../FATFS/App;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FatFs/src;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../Bsp;../Drivers/USER/APP;../user;..\CMSIS\Include;..\user
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0xc0000
  scatter file: BJC_2\BJC_2.sct
  group Application/MDK-ARM
    ./: startup_stm32h750xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c i2c.c mdma.c sdmmc.c spi.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Application/User/FATFS/Target
    ../FATFS/Target/: bsp_driver_sd.c sd_diskio.c fatfs_platform.c
  group Application/User/FATFS/App
    ../FATFS/App/: fatfs.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_ll_sdmmc.c stm32h7xx_ll_delayblock.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c ccsbcs.c
  group USER/APP
    ../Drivers/USER/APP/: APP_Work.c APP_Work.h
  group user
    ../user/: ad7767.c ad7767.h SDTest.c SDTest.h mpu6050.c mpu6050.h max3221.c max3221.h ds1302.c ds1302.h demodu.c demodu.h
  group CMSIS/DSP
    ../CMSIS/Source/TransformFunctions/: TransformFunctions.c
    ../CMSIS/Source/FastMathFunctions/: FastMathFunctions.c
    ../CMSIS/Source/BasicMathFunctions/: BasicMathFunctions.c
    ../CMSIS/Source/CommonTables/: CommonTables.c
    ../CMSIS/Source/ComplexMathFunctions/: ComplexMathFunctions.c
    ../CMSIS/Source/ControllerFunctions/: ControllerFunctions.c
    ../CMSIS/Source/FilteringFunctions/: FilteringFunctions.c
    ../CMSIS/Source/MatrixFunctions/: MatrixFunctions.c
    ../CMSIS/Source/StatisticsFunctions/: StatisticsFunctions.c
    ../CMSIS/Source/SupportFunctions/: SupportFunctions.c
software components: CMSIS:CORE 5.4.0, Compiler:Event Recorder 1.5.1, Compiler:I/O:STDOUT 1.2.0
